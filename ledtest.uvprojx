# Keil uVision project ledtest.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: ledtest
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c drv_leds.c setup.c utils.c
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s stm32f4xx_conf.h system_stm32f4xx.c
    C:/Program Files (x86)/Keil v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0
